* Wheatstone Bridge

V1 1 0 24; 24 volt source
R1 1 2 150; 150 ohm resistor
R2 1 3 50; 50 ohm resistor
R3 2 3 100; 100 ohm resistor
R4 2 0 300; 300 ohm resistor
R5 3 0 250; 250 ohm resistor
