* Series RLC Circuit

V1 1 0 20; 20 volt source
R1 2 1 10; 10 ohm resistor
L1 2 3 5; 5 henry inductor
C1 3 0 3; 3 farad capacitor
